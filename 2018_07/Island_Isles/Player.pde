class player{
  float speed = 1;
  
   int[] hotbar = new int[10];
   int[][] inventory = new int[10][5];
  
  color[][] modelPalette = {
  {color(255,0),color(65,25,8),color(40,27,40),color(248,208,184),color(211,135,102),color(104,77,64),color(133,149,161),color(222,238,214),color(78),color(128,103,91),color(142,107,87),color(0),color(51,6,45),color(38,12,60),color(110,61,54)},
  {color(255,0),color(65,25,8),color(40,27,40),color(248,208,184),color(211,135,102),color(104,77,64),color(133,149,161),color(222,238,214),color(78),color(128,103,91),color(142,107,87),color(0),color(51,6,45),color(38,12,60),color(110,61,54)},
};
  int[][][] models = {
    {
      {0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0},
      {0,0,0,0,0,0,0,1,1,1,0,1,0,0,0,0},
      {0,0,0,0,0,0,1,10,10,10,1,10,1,0,0,0},
      {0,0,0,0,1,1,1,10,10,10,10,10,1,0,0,0},
      {0,0,0,1,5,1,10,10,10,10,10,10,10,1,0,0},
      {0,0,1,5,1,10,5,10,5,5,10,10,5,1,0,0},
      {0,0,1,1,5,5,5,5,5,5,5,5,5,10,1,0},
      {1,1,5,5,5,5,1,1,1,1,1,1,5,5,1,1},
      {5,5,5,5,1,1,12,12,14,14,2,2,1,5,5,1},
      {1,1,1,1,12,2,2,4,4,4,4,4,1,1,1,0},
      {0,13,12,12,2,1,1,1,3,4,1,1,1,0,0,0},
      {0,13,12,2,5,4,11,3,3,3,3,11,1,0,0,0},
      {0,13,0,1,5,9,4,3,3,3,3,5,1,0,0,0},
      {0,0,0,1,1,5,9,9,9,9,9,1,0,0,0,0},
      {0,0,1,7,6,2,2,2,2,1,1,0,0,0,0,0},
      {0,0,1,6,2,6,7,8,4,6,2,0,0,0,0,0},
      {0,0,1,3,3,2,6,7,8,7,2,0,0,0,0,0},
      {0,0,1,4,3,2,6,2,6,8,2,0,0,0,0,0},
      {0,0,0,1,2,5,2,0,2,5,1,0,0,0,0,0},
      {0,0,0,0,1,2,0,0,1,2,0,0,0,0,0,0},
    },
    {
      {0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0},
      {0,0,0,0,0,0,0,1,1,1,0,1,0,0,0,0},
      {0,0,0,0,0,0,1,10,10,10,1,10,1,0,0,0},
      {0,0,0,0,1,1,1,10,10,10,10,10,1,0,0,0},
      {0,0,0,1,5,1,10,10,10,10,10,10,10,1,0,0},
      {0,0,1,5,1,10,5,10,5,5,10,10,5,1,0,0},
      {0,0,1,1,5,5,5,5,5,5,5,5,5,10,1,0},
      {1,1,5,5,5,5,1,1,1,1,1,1,5,5,1,1},
      {5,5,5,5,1,1,12,12,14,14,2,2,1,5,5,1},
      {1,1,1,1,12,2,2,4,4,4,4,4,1,1,1,0},
      {0,13,12,12,2,1,1,1,3,4,1,1,1,0,0,0},
      {0,13,12,2,5,4,11,3,3,3,3,11,1,0,0,0},
      {0,13,0,1,5,9,4,3,3,3,3,5,1,0,0,0},
      {0,0,0,1,1,5,9,9,9,9,9,1,0,0,0,0},
      {0,0,1,7,6,2,2,2,2,1,1,0,0,0,0,0},
      {0,0,1,6,2,6,7,8,4,6,2,0,0,0,0,0},
      {0,0,1,3,3,2,6,7,8,7,2,0,0,0,0,0},
      {0,0,1,4,3,2,6,2,6,8,2,0,0,0,0,0},
      {0,0,0,1,2,5,2,0,2,5,1,0,0,0,0,0},
      {0,0,0,0,0,1,2,0,0,1,2,0,0,0,0,0},
    },
  };
  PVector shift = playerWorldCords.mult(-1);
  
  PVector pos = new PVector(0,0);
  PVector vel = new PVector(0,0);
  PVector acc = new PVector(0,0);
  player(PVector p){
    pos = p.copy();
  }
  void update(){
    
    
    
    shift = playerWorldCords.copy().mult(-1);
    shift.x-=width/2;
    shift.y-=height/2;
    vel.add(acc);
    pos.add(vel);
    playerWorldCords = pos.copy();
    vel.mult(0.8);
    acc.mult(0);
  }
  void display(){
    float scl = scale;
    if(vel.x<0){
      modelCreator(1,pos.x-shift.copy().x,pos.y-shift.copy().y,scl,scl,16);
    }else{
      modelCreator(0,pos.x-shift.copy().x,pos.y-shift.copy().y,scl,scl,16);
    }
    fill(0);
    //fill(0);
    //rectMode(CENTER);
    //rect(pos.x-shift.x,pos.y-shift.y,scl,scl);
  }
  void move(){
    if(w){
      acc.y-=speed;
    }if(s){
      acc.y+=speed;
    }if(d){
      acc.x+=speed;
    }if(a){
      acc.x-=speed;
    }
  }
  private void modelCreator(int id,float x,float y,float iw,float ih,int bit){
    noStroke();
    smooth();
    for(int h = 0;h< models[id].length;h++){
      for(int w = 0;w < models[id][0].length;w++){
        fill(modelPalette[id][models[id][h][w]]);
        rect(x+w*iw/bit,y+h*ih/bit,iw/bit,ih/bit);
      }
    }
  }
}